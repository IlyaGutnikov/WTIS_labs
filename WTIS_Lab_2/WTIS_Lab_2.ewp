# IAR project WTIS_Lab_2.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430FG4618 MSP430FG4618
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MSP430FG4618
  ICC430.newCCIncludePaths: ; scmRTOS\Common\; scmRTOS\MSP430\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 1
  A430.ADefines: MSP430FG4618
  A430.AUserIncludes: as above
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430FG4618.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: cc2420.c cc2420.h main.cpp sensors.c sensors.h system.c system.h uart.c uart.h
  group scmRTOS
    ./: scmRTOS_config.h scmRTOS_extensions.h scmRTOS_TARGET_CFG.h
  group scmRTOS/common
    scmRTOS/Common/: OS_Kernel.cpp OS_Kernel.h OS_Services.cpp OS_Services.h scmRTOS.h scmRTOS_310_compat.h scmRTOS_defs.h usrlib.cpp usrlib.h
  group scmRTOS/msp430
    scmRTOS/MSP430/: OS_Target.h OS_Target_asm.s43 OS_Target_cpp.cpp
